# Keil uVision project qixiangzhan.uvprojx, settings and files
target qixiangzhan (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: qixiangzhan +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../HARDWARE;../HARDWARE/APP;../HARDWARE/RElAY;../HARDWARE/KEY;../HARDWARE/L610;../HARDWARE/PROTOCOL;../HARDWARE/CONSOLE;../HARDWARE/WEATHER;../HARDWARE/PANEL_LINK;../HARDWARE/LCD
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group HARDWARE
    ../HARDWARE/APP/: app_main.c app_main.h
    ../HARDWARE/RElAY/: relay.c relay.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/L610/: l610.c l610.h l610_mqtt.h l610_mqtt.c
    ../HARDWARE/PROTOCOL/: protocol.c protocol.h
    ../HARDWARE/CONSOLE/: console.c console.h
    ../HARDWARE/WEATHER/: app_weather.c bsp_uart.c board_rs485.c uart_ringbuf.c modbus_rtu.c sensor_wind_zts.c sensor_air_cj702.c sensor_rain.c weather_data.c app_weather.h bsp_uart.h board_rs485.h uart_ringbuf.h modbus_rtu.h sensor_wind_zts.h sensor_air_cj702.h sensor_rain.h weather_data.h
    ../HARDWARE/PANEL_LINK/: panel_link.c panel_link.h
    ../HARDWARE/LCD/: lcd_port.c lcd_port.h lcd_touch.c lcd_touch.h lcd_ui_model.c lcd_ui_model.h lcd_ui_pages.c lcd_ui_pages.h lcd_debug_ui.c lcd_debug_ui.h
software components: CMSIS:CORE 4.3.0
